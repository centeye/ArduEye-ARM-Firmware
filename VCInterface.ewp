# IAR project VCInterface.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F215rx ST STM32F215rx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F2XX; USE_STM322xG_EVAL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; app\; board\; library\STM32F2xx_StdPeriph_Driver\inc\; library\CMSIS\CM3\CoreSupport\; library\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; library\STM32F2xx_StdPeriph_Template\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: VCInterface.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: library\STM32F2xx_StdPeriph_Template\EWARM\stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    library/STM32F2xx_StdPeriph_Template/: stm32f2xx_it.c
  group CMSIS
    library/CMSIS/CM3/CoreSupport/: core_cm3.c
    library/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    library/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Content
    app/: DataComm.cpp Firefly.cpp FlashManager.cpp ImageProcessing.cpp main.cpp Stonyman.cpp TAM.cpp Timers.cpp VisionChip.cpp
  group Periph
    library/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c
